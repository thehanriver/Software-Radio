options:
  parameters:
    generate_options: qt_gui
    id: transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 2e4
  states: {}
- name: filter_cutoff
  id: variable
  parameters:
    value: 2*fsk_deviation_hz
  states: {}
- name: filter_transition
  id: variable
  parameters:
    value: '250'
  states: {}
- name: fsk_deviation_hz
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 5e3
  states: {}
- name: gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '20'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /ad/eng/users/g/d/gdevlin/Desktop/EC415/project/TransmitTest_pt1.iq
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gdevlin/Desktop/EC415/project/M4_TrasmitterFlowgraphCheck.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: samples_per_symbol
    sensitivity: (2*math.pi*fsk_deviation_hz)/samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [blocks_multiply_xx_0, '0', blocks_file_sink_0, '0']
- [digital_gfsk_mod_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
